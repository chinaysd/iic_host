# IAR project ST_IIC.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: C:\Users\Administrator\Desktop\ST_IIC\bsp; C:\Users\Administrator\Desktop\ST_IIC\iic; C:\Users\Administrator\Desktop\ST_IIC\lib\inc; C:\Users\Administrator\Desktop\ST_IIC\TimeOut; C:\Users\Administrator\Desktop\ST_IIC\user; C:\Users\Administrator\Desktop\ST_IIC\iic\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ST_IIC.srec
  ILINK.IlinkOutputFile: ST_IIC.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group bsp
    ../bsp/: bsp_led.c
    ../iic/src/: iic.c
    ../iic/port/: iic_port.c
  group lib
    ../lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group user
    ../user/: main.c stm8s_it.c system.c
